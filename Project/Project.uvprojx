# Keil uVision project Project.uvprojx, settings and files
target STM32F446RE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ..\Application;..\Driver;..\Device;..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\Library\CMSIS\Include;..\Library\STM32F4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../Application/: main.c board.c stm32f4xx_it.c
  group Driver
    ../Driver/: uart.c i2s.c
  group Device
    ../Device/: led.c
  group CMSIS
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f446xx.s
  group STM32F4xx_HAL_Driver
    ../Library/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c
